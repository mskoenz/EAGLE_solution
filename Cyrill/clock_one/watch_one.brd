# Repository mskoenz/EAGLE_solution

## EAGLE design Cyrill/clock_one/watch_one.brd

Parts:
JP1, JP3, JP4: M02PTH; 1X02
JP2, JP6: M03PTH; 1X03
JP5, JP7, JP8, JP9: M01SMD; LUXEON-PAD
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11: LED3MM
SL1, SL2: M02; 02P
U1: ATMEGA328P_PDIP; DIL28-3
Y1: CRYSTALHC49US; HC49US

Connections:
GND: JP1.1, JP5.P$1, JP6.2, JP9.P$1, SL1.1, SL2.1, U1.8 (GND), U1.22 (GND)
unnamed: LED5.K (C), U1.19 (PB5(SCK))
unnamed: LED4.K (C), U1.18 (PB4(MISO))
unnamed: JP2.1, U1.1 (PC6(/RESET))
unnamed: JP2.3, U1.3 (PD1(TXD))
unnamed: JP2.2, U1.2 (PD0(RXD))
unnamed: LED2.K (C), U1.17 (PB3(MOSI/OC2))
unnamed: LED1.K (C), U1.15 (PB1(OC1A))
unnamed: LED8.K (C), U1.14 (PB0(ICP))
unnamed: LED7.K (C), U1.13 (PD7(AIN1))
unnamed: LED3.K (C), U1.12 (PD6(AIN0))
unnamed: LED9.K (C), U1.11 (PD5(T1))
unnamed: LED10.K (C), U1.6 (PD4(XCK/T0))
unnamed: LED6.K (C), U1.16 (PB2(SS/OC1B))
unnamed: JP6.3, U1.4 (PD2(INT0))
unnamed: SL1.2, U1.9 (PB6(XTAL1/TOSC1)), Y1.1
unnamed: SL2.2, U1.10 (PB7(XTAL2/TOSC2)), Y1.2
unnamed: JP4.2, U1.23 (PC0(ADC0))
SWAP1: JP3.2, U1.5 (PD3(INT1))
SWAP2: LED11.K (C), U1.24 (PC1(ADC1))
VCC: JP1.2, JP3.1, JP4.1, JP6.1, JP7.P$1, JP8.P$1, LED1.A, LED2.A, LED3.A, LED4.A, LED5.A, LED6.A, LED7.A, LED8.A, LED9.A, LED10.A, LED11.A, U1.7 (VCC), U1.20 (AVCC), U1.21 (AREF)

Board: 2 copper layers, 101.6 x 41.9 mm, 24 parts (0 on the bottom side), 21 nets.

File tipps/used_parts_TicTacToe.txt:

The following parts are needed in the TicTacToe project:

1 x ATMEGA328P_PDIP

note: PD0-PD7 is Digital Pin 0-7
      PB0-PB5 is Digital Pin 8-13 
      PC0-PC5 is Analog  Pin 0-5

3 x TAC_SWITCHPTH

note: has 4 pins but 2 each are already connected (you know this from the button, right?)
      use as INPUT_PULLUP, meaning one side to GND, other side to Digital Pin of the ATMEGA
      !one button has to connect to Pin 2 or Pin 3 bc of the interrupt to return from sleep

9 x DUOLED-RG-C

note: has common cathode (VCC)
      middle part to VCC
      outer pins to ATMEGA or PCF8574

1 x PCF8574P

note: VSS == GND
      INT doesn't need to be attached
      SCL/SDA needs to go to the ATMEGA
      set A0, A1, A2 to GND

1 x M02PTH

note: to connect the battery / one is GND the other is VCC

1 x M03PTH

note: to connect RX/TX/RST (pin 0, pin 1, pin reset) in order to program the ATMEGA on the board

1 x M04PTH

note: to connect the piezo element
      don't connect the middle two contacts
      one of the outer goes to GND or VCC and the other to a Digital Pin on the ATMEGA

1 x DIL8S

note: this is used to mount the crystal and the caps (so that you can take it out again, like the ICs). I recommend the following (or similar) layout. You don't need to add crystals or caps

XTAL1-+----O crystal O----+-XTAL2
      | x--O nothing O--x |
      |    O-+ cap   O----+
      +----O | cap   O--+---GND
             +----------+

final notes:

In schematic:
-place parts with "Add"
-connect pins with "Net" ("Wire" works also but I don't recommend)
-name your lines with "Name" (i.e. GND)
-if you want to display the name of a line use "Label"
-it's enough if two lines have the same name, the don't need to be connected visible in the schematic

In board: (file -> switch to board)
-"Route" on the bottom layer (most/all your connections should be blue not red) bc. it's easier to solder afterwards
-Correct bad "Route" with "Ripup"
-try to minimize the use of "Via" (changes from to to bottom)
-you can use the default setting with trackwidth 0.016 inch and the default grid spacing
-route all but the LEDs with the schematic-board connected
-at the end move the schematic to another folder and "Signal" and "Route" the LED on the board
-alternatively: just use "Wire" instead of "Route" in the board modus, so you don't need do disconnect the schematic/board

Finish (all in board modus):
-Adjust gray dimension square to fit the project tightly (smaller board->cheaper)
-If there is no dimension square, use "Rectangle" and draw in the dimension layer (not top or bottom)
-use "Polygon" and draw polygons on top and/or bottom that follow the gray dimension square (a polygon is only valid if the end meets the start exactly)
-Click on the "DRC" tool
-Click on load… and load the proper design rules i.e. bastli/bastli.dru
-You don't need to "check", just "select/apply"
-Now use the "Autoroute" tool and load bastli/bastli.ctl
-Hit "Ok". The polygons should now be gone and all empty areas filled with top or bottom color

Export:
-click file/CAM-Processor
-Export the different layers as follows:

TOP:
device:                GERBER_RS274X
only selected Layers:  Top, Pads, Vias
filename (convention): TOP

hit execute job (TOP and TOP.gpi are now created->TOP.gpi is not important)

BOTTOM:
device:                GERBER_RS274X
only selected Layers:  Bottom, Pads, Vias
filename (convention): BOTTOM

hit execute job (BOTTOM and BOTTOM.gpi are now created->BOTTOM.gpi is not important)

OUTLINE:
device:                GERBER_RS274X
only selected Layers:  Dimension
filename (convention): OUTLINE

hit execute job (OUTLINE and OUTLINE.gpi are now created->OUTLINE.gpi is not important)

DRILL:
device:                EXCELLON
only selected Layers:  Drill, Holes
filename (convention): DRILL

hit execute job (DRILL and DRILL.dri are now created->DRILL.dri is not important)

You need minimally a TOP or BOTTOM file as well as an OUTLINE file.

Go to http://www.gerber-viewer.com/ and load your files just to double-check them…

If all is ok->

Order:
-You have to be in the ETH network->VPN
-go to https://pcb.mueslo.de/ or search for PCB-Tool on the bastli homepage and press "Order a PCB"
-Choose Pool
-Choose for the material FR4 35u -> copper layer is 35um thick (you can bring your own material if you need something different)
-drag and drop the files onto the right slots on the homepage
-add name, phone and email and order

## EAGLE design Dominik/proj1.brd

Board: 2 copper layers, 55.6 x 74.9 mm, 18 parts (0 on the bottom side), 30 nets.

Parts:
IC1: PCF8574P; DIL16
IC2: SOCKET-08
JP1: M02PTH; 1X02
JP2: 1X03
JP3: 1X04
LD1, LD2, LD3, LD4, LD5, LD6, LD7, LD8, LD9: DUOLED-C-5MM
S1, S2, S3: TACTILE-PTH
U1: ATMEGA328P_PDIP; DIL28-3

Connections:
BTN0: S1.1, U1.4
BTN1: S2.1, U1.5
BTN2: S3.1, U1.6
LED0_1: LD4.AX, U1.25
LED0_2: LD4.AR, U1.26
LED1_1: IC1.7, LD7.AX
LED1_2: LD7.AR, U1.18
LED2_2: LD9.AR, U1.14
LED3_1: IC1.12, LD1.AX
LED3_2: IC1.11, LD1.AR
LED4_1: IC1.6, LD6.AX
LED5_1: LD8.AX, U1.16
LED5_2: LD8.AR, U1.13
LED6_1: IC1.9, LD2.AX
LED6_2: IC1.10, LD2.AR
LED7_1: IC1.4, LD3.AX
LED7_2: IC1.5, LD3.AR
LED8_1: LD5.AX, U1.15
LED8_2: LD5.AR, U1.12
unnamed: JP2.1, U1.1
unnamed: IC2.6, IC2.8, U1.9
unnamed: IC2.1, IC2.5, U1.10
unnamed: IC1.1, IC1.3, IC1.16, JP1.2, LD1.C, LD2.C, LD3.C, LD4.C, LD5.C, LD6.C, LD7.C, LD8.C, LD9.C, U1.7, U1.20, U1.21
unnamed: LD9.AX, U1.17
unnamed: IC1.8, IC2.3, IC2.4, JP3.4, S1.3, S2.3, S3.3, U1.22
PIEZO: JP3.1, U1.11
S$2: JP2.2, U1.2
S$9: IC1.14, U1.28
S$10: IC1.15, U1.27
S$12: JP2.3, U1.3

## Commit log

2013-11-15 1.Commit: setting up the structure
2013-11-15 2.Commit: added usr-folder
2013-11-15 3.Commit: renamed hpp->txt
2013-11-15 test
2013-11-15 removed test
2013-11-15 Test push rights.
2013-11-15 new test using SSH
2013-11-15 removed test2
2013-11-15 test commit1
2013-11-15 hello
2013-11-15 first try...
2013-11-15 4.Commit: cleaned repo
2013-11-15 5.Commit: added Tips and EAGLE_tools.tiff
2013-11-15 6.Commit: renamed folders
2013-11-15 7.Commit: one button has to connect to interrupt channel
2013-11-16 first draft of the board
2013-11-16 moved a few wires
2013-11-16 fixed a few issues
2013-11-16 First Try
2013-11-17 optimization
2013-11-17 added question
2013-11-17 changed wire near buttons
2013-11-17 version 2
2013-11-18 3 try
2013-11-18 Tim Solution Finish
2013-11-19 added board1 andreas
2013-11-19 7.Commit: added my solution
2013-11-19 next try :P
2013-11-19 added version2
2013-11-19 add schematic
2013-11-19 andu final solution
2013-11-19 frei_final
2013-11-19 final2
2013-11-19 final3
2013-11-20 ricoh: almost finish schematic, add board, route.
    * schematic: PCF VCC and GND are still switched up (fixed in brd)
    * board: ready for review.
2013-11-20 final version
2013-11-20 tictactoe board+schematic
2013-11-20 ricoh: version 2 of board
    * connect vcc branches
    * disconnect unused pin on DIP8S
    * reroute buttons to pins 2-4
    * reroute piezo to use pin 5
    * more efficient routing overall
2013-11-20 ricoh: board version 3
    * swap XTAL1 & XTAL2
    * shift M04 to leave space for piezo module
    * relax routing around LD8
    * adjust board size
2013-11-20 version 2 (fixes) and a more compact one
2013-11-20 tiny improvement (rotated LED)
2013-11-20 8.Commit: added finish instructions
2013-11-20 fix: LED3 connection through JP3
2013-11-20 added 2nd ground and rotated LD4
2013-11-20 Piezo on VCC instead of ground (simplification)
2013-11-20 tiny fixes
2013-11-20 tiny fixes #2
2013-11-20 tiny fixes #3
2013-11-20 added bastli files
2013-11-20 question
2013-11-20 ricoh: final version -> bestellen
2013-11-20 added adapter design
2013-11-26 add pin mapping list.
2013-11-26 pinmapping
2013-11-27 added pinmap
2013-11-27 added second adapter
2013-11-28 added mapping andreas
2013-11-29 9.Commit: cleaned structure
2013-12-02 added tictactoe design
2013-12-02 small changes
2013-12-02 new version
2013-12-04 minor change
2013-12-05 created printing supports
2013-12-05 added .stl files
2013-12-05 updated bottom
2013-12-05 add tictactoe.stl with 3d-design for case.
2013-12-05 update design to leave space for optional top plate.
    top plate to be added at a later time...
2013-12-06 add tictactoe_mm, scaled to meet expectations of the MakerBot
2013-12-06 update tictactoe_mm.stl, rendering tictactoe.stl obsolete.
2013-12-14 clock_one try1
2013-12-14 clock_try2
2013-12-14 clock_try3
2013-12-15 clock_one minor adjustments pcb
2013-12-16 included BOTTOM TOP DRILL OUTLINE
2013-12-16 OUTLINE TOP BOTTOM DRILL tilt sensor to A0 correction
2013-12-17 schaltplan update
2013-12-17 schaltplan next
2013-12-17 schaltplan next 2
2013-12-17 TOP BOTTOM OUTLINE DRILL next

Notices in the files:
parts and their libraries:
SparkFun-DigitalIC: Licensing: CC v3.0 Share-Alike You are welcome to use this library for commercial purposes.
