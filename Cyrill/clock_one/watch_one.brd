File: Cyrill/clock_one/watch_one.brd (EAGLE design)
At the start: 100 x 80 mm, 22 parts, among them U1 ATMEGA328P_PDIP

Commit message: clock_try2
Parts:
- removed IC1: (no value), ic-package:SOCKET-08
- added SL1, SL2: (no value), con-amp-quick:02P
- added Y1: (no value), SparkFun-FreqCtrl:HC49US
- JP5, JP7, JP8, JP9: value M01PTH_2MM -> M01SMD; device SparkFun-Connectors:1X01_2MM -> SparkFun-Connectors:LUXEON-PAD
- turned JP5 to 90 degrees
- turned JP7 to 90 degrees
- turned JP8 to 90 degrees
- turned JP9 to 90 degrees
Connections:
- net GND: now also JP5.P$1, JP9.P$1, SL1.1, SL2.1; no longer IC1.3, IC1.5, JP5.1, JP9.1
- net N$19: now also SL1.2, Y1.1; no longer IC1.1, IC1.4
- net N$20: now also SL2.2, Y1.2; no longer IC1.6, IC1.8
- net VCC: now also JP7.P$1, JP8.P$1; no longer JP7.1, JP8.1
Routing:
- net N$20: track 26.7 -> 8.89 mm
- net N$19: track 36.8 -> 21.6 mm
- net GND: track 215.9 -> 210.8 mm
- net N$16: track 80.0 -> 77.5 mm
- net N$11: track 90.2 -> 87.6 mm
- net N$10: track 95.2 -> 92.7 mm
Changed lines of the file:
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@@
 <element name="LED10" library="SparkFun-LED" package="LED3MM" value="" x="91.44" y="39.37" rot="R90"/>
 <element name="LED11" library="SparkFun-LED" package="LED3MM" value="" x="96.52" y="39.37" rot="R90"/>
-<element name="JP5" library="SparkFun-Connectors" package="1X01_2MM" value="M01PTH_2MM" x="52.07" y="25.4"/>
-<element name="JP7" library="SparkFun-Connectors" package="1X01_2MM" value="M01PTH_2MM" x="24.13" y="25.4"/>
-<element name="JP8" library="SparkFun-Connectors" package="1X01_2MM" value="M01PTH_2MM" x="24.13" y="53.34"/>
-<element name="JP9" library="SparkFun-Connectors" package="1X01_2MM" value="M01PTH_2MM" x="52.07" y="53.34"/>
-<element name="IC1" library="ic-package" package="SOCKET-08" value="" x="6.35" y="16.51" rot="R270"/>
+<element name="JP5" library="SparkFun-Connectors" package="LUXEON-PAD" value="M01SMD" x="52.07" y="25.4" rot="R90"/>
+<element name="JP7" library="SparkFun-Connectors" package="LUXEON-PAD" value="M01SMD" x="24.13" y="25.4" rot="R90"/>
+<element name="JP8" library="SparkFun-Connectors" package="LUXEON-PAD" value="M01SMD" x="24.13" y="53.34" rot="R90"/>
+<element name="JP9" library="SparkFun-Connectors" package="LUXEON-PAD" value="M01SMD" x="52.07" y="53.34" rot="R90"/>
+<element name="Y1" library="SparkFun-FreqCtrl" package="HC49US" value="" x="5.08" y="33.02"/>
+<element name="SL1" library="con-amp-quick" package="02P" value="" x="3.81" y="22.86" rot="R180">
+<attribute name="OC_NEWARK" value="unknown" x="3.81" y="22.86" size="1.778" layer="27" rot="R180" display="off"/>
+<attribute name="MPN" value="" x="3.81" y="22.86" size="1.778" layer="27" rot="R180" display="off"/>
+<attribute name="MF" value="" x="3.81" y="22.86" size="1.778" layer="27" rot="R180" display="off"/>
+<attribute name="OC_FARNELL" value="unknown" x="3.81" y="22.86" size="1.778" layer="27" rot="R180" display="off"/>
+</element>
+<element name="SL2" library="con-amp-quick" package="02P" value="" x="6.35" y="27.94">
+<attribute name="OC_NEWARK" value="unknown" x="6.35" y="27.94" size="1.778" layer="27" display="off"/>
+<attribute name="MPN" value="" x="6.35" y="27.94" size="1.778" layer="27" display="off"/>
+<attribute name="MF" value="" x="6.35" y="27.94" size="1.778" layer="27" display="off"/>
+<attribute name="OC_FARNELL" value="unknown" x="6.35" y="27.94" size="1.778" layer="27" display="off"/>
+</element>
 </elements>
 <signals>
@@
 </signal>
 <signal name="GND">
-<contactref element="JP9" pad="1"/>
-<contactref element="JP5" pad="1"/>
+<contactref element="JP9" pad="P$1"/>
+<contactref element="JP5" pad="P$1"/>
 <contactref element="JP1" pad="1"/>
 <contactref element="U1" pad="8"/>
@@
 <wire x1="25.4" y1="27.94" x2="26.67" y2="27.94" width="0.4064" layer="1"/>
 <wire x1="26.67" y1="27.94" x2="26.67" y2="25.4" width="0.4064" layer="1"/>
-<contactref element="IC1" pad="3"/>
-<contactref element="IC1" pad="5"/>
-<wire x1="2.54" y1="15.24" x2="6.35" y2="15.24" width="0.4064" layer="16"/>
-<wire x1="6.35" y1="15.24" x2="6.35" y2="12.7" width="0.4064" layer="16"/>
-<wire x1="6.35" y1="12.7" x2="10.16" y2="12.7" width="0.4064" layer="16"/>
-<wire x1="10.16" y1="12.7" x2="12.7" y2="12.7" width="0.4064" layer="16"/>
-<wire x1="12.7" y1="12.7" x2="12.7" y2="16.51" width="0.4064" layer="16"/>
-<wire x1="12.7" y1="16.51" x2="52.07" y2="16.51" width="0.4064" layer="16"/>
-<wire x1="52.07" y1="16.51" x2="52.07" y2="25.4" width="0.4064" layer="16"/>
+<wire x1="52.07" y1="20.32" x2="52.07" y2="25.4" width="0.4064" layer="1"/>
+<contactref element="SL1" pad="1"/>
+<contactref element="SL2" pad="1"/>
+<wire x1="5.08" y1="22.86" x2="5.08" y2="27.94" width="0.4064" layer="16"/>
+<wire x1="5.08" y1="22.86" x2="8.89" y2="22.86" width="0.4064" layer="1"/>
+<wire x1="8.89" y1="22.86" x2="8.89" y2="20.32" width="0.4064" layer="1"/>
+<wire x1="8.89" y1="20.32" x2="52.07" y2="20.32" width="0.4064" layer="1"/>
 </signal>
 <signal name="VCC">
@@
 <contactref element="LED4" pad="A"/>
 <contactref element="LED5" pad="A"/>
-<contactref element="JP7" pad="1"/>
-<contactref element="JP8" pad="1"/>
+<contactref element="JP7" pad="P$1"/>
+<contactref element="JP8" pad="P$1"/>
 <contactref element="U1" pad="7"/>
 <contactref element="U1" pad="21"/>
@@
 <contactref element="LED8" pad="K"/>
 <wire x1="11.43" y1="22.86" x2="13.97" y2="22.86" width="0.4064" layer="16"/>
-<wire x1="13.97" y1="22.86" x2="13.97" y2="17.78" width="0.4064" layer="16"/>
-<wire x1="13.97" y1="17.78" x2="46.99" y2="17.78" width="0.4064" layer="16"/>
-<wire x1="46.99" y1="17.78" x2="46.99" y2="27.94" width="0.4064" layer="16"/>
+<wire x1="13.97" y1="22.86" x2="13.97" y2="19.05" width="0.4064" layer="16"/>
+<wire x1="13.97" y1="19.05" x2="46.99" y2="19.05" width="0.4064" layer="16"/>
+<wire x1="46.99" y1="19.05" x2="46.99" y2="27.94" width="0.4064" layer="16"/>
 <wire x1="46.99" y1="27.94" x2="81.28" y2="27.94" width="0.4064" layer="16"/>
 <wire x1="81.28" y1="27.94" x2="81.28" y2="38.1" width="0.4064" layer="16"/>
@@
 <contactref element="LED7" pad="K"/>
 <wire x1="11.43" y1="25.4" x2="15.24" y2="25.4" width="0.4064" layer="16"/>
-<wire x1="15.24" y1="25.4" x2="15.24" y2="19.05" width="0.4064" layer="16"/>
-<wire x1="15.24" y1="19.05" x2="45.72" y2="19.05" width="0.4064" layer="16"/>
-<wire x1="45.72" y1="19.05" x2="45.72" y2="29.21" width="0.4064" layer="16"/>
+<wire x1="15.24" y1="25.4" x2="15.24" y2="20.32" width="0.4064" layer="16"/>
+<wire x1="15.24" y1="20.32" x2="45.72" y2="20.32" width="0.4064" layer="16"/>
+<wire x1="45.72" y1="20.32" x2="45.72" y2="29.21" width="0.4064" layer="16"/>
 <wire x1="45.72" y1="29.21" x2="76.2" y2="29.21" width="0.4064" layer="16"/>
 <wire x1="76.2" y1="29.21" x2="76.2" y2="38.1" width="0.4064" layer="16"/>
@@
 <wire x1="71.12" y1="38.1" x2="71.12" y2="30.48" width="0.4064" layer="16"/>
 <wire x1="71.12" y1="30.48" x2="44.45" y2="30.48" width="0.4064" layer="16"/>
-<wire x1="44.45" y1="30.48" x2="44.45" y2="20.32" width="0.4064" layer="16"/>
-<wire x1="44.45" y1="20.32" x2="16.51" y2="20.32" width="0.4064" layer="16"/>
-<wire x1="16.51" y1="20.32" x2="16.51" y2="25.4" width="0.4064" layer="16"/>
+<wire x1="44.45" y1="30.48" x2="44.45" y2="21.59" width="0.4064" layer="16"/>
+<wire x1="44.45" y1="21.59" x2="16.51" y2="21.59" width="0.4064" layer="16"/>
+<wire x1="16.51" y1="21.59" x2="16.51" y2="25.4" width="0.4064" layer="16"/>
 <wire x1="16.51" y1="25.4" x2="19.05" y2="25.4" width="0.4064" layer="16"/>
 </signal>
 <signal name="N$19">
-<contactref element="IC1" pad="1"/>
-<contactref element="IC1" pad="4"/>
 <contactref element="U1" pad="9"/>
-<wire x1="2.54" y1="12.7" x2="0" y2="12.7" width="0.4064" layer="16"/>
-<wire x1="0" y1="12.7" x2="0" y2="20.32" width="0.4064" layer="16"/>
-<wire x1="0" y1="20.32" x2="2.54" y2="20.32" width="0.4064" layer="16"/>
-<wire x1="11.43" y1="35.56" x2="2.54" y2="35.56" width="0.4064" layer="16"/>
-<wire x1="2.54" y1="35.56" x2="2.54" y2="20.32" width="0.4064" layer="16"/>
+<contactref element="Y1" pad="1"/>
+<contactref element="SL1" pad="2"/>
+<wire x1="2.54" y1="33.02" x2="2.54" y2="35.56" width="0.4064" layer="16"/>
+<wire x1="2.54" y1="35.56" x2="11.43" y2="35.56" width="0.4064" layer="16"/>
+<wire x1="2.54" y1="33.02" x2="2.54" y2="22.86" width="0.4064" layer="16"/>
 </signal>
 <signal name="N$20">
-<contactref element="IC1" pad="8"/>
 <contactref element="U1" pad="10"/>
-<contactref element="IC1" pad="6"/>
-<wire x1="11.43" y1="33.02" x2="7.62" y2="33.02" width="0.4064" layer="16"/>
-<wire x1="7.62" y1="33.02" x2="7.62" y2="20.32" width="0.4064" layer="16"/>
-<wire x1="7.62" y1="20.32" x2="10.16" y2="20.32" width="0.4064" layer="16"/>
-<wire x1="10.16" y1="15.24" x2="7.62" y2="15.24" width="0.4064" layer="16"/>
-<wire x1="7.62" y1="15.24" x2="7.62" y2="20.32" width="0.4064" layer="16"/>
+<contactref element="Y1" pad="2"/>
+<contactref element="SL2" pad="2"/>
+<wire x1="7.62" y1="33.02" x2="11.43" y2="33.02" width="0.4064" layer="16"/>
+<wire x1="7.62" y1="33.02" x2="7.62" y2="27.94" width="0.4064" layer="16"/>
 </signal>
 </signals>

Commit message: included BOTTOM TOP DRILL OUTLINE
Routing:
- added copper zone on layer 1, net N$21
- added copper zone on layer 16, net N$8
Other:
- board size 100 x 80 mm -> 104.1 x 41.9 mm
Changed lines of the file:
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@@
 <board>
 <plain>
-<wire x1="0" y1="0" x2="100" y2="0" width="0" layer="20"/>
-<wire x1="100" y1="0" x2="100" y2="80" width="0" layer="20"/>
-<wire x1="100" y1="80" x2="0" y2="80" width="0" layer="20"/>
-<wire x1="0" y1="80" x2="0" y2="0" width="0" layer="20"/>
-<dimension x1="24.13" y1="25.4" x2="52.07" y2="25.4" x3="38.1" y3="13.970003125" textsize="1.778" layer="16"/>
-<dimension x1="24.13" y1="53.34" x2="52.07" y2="53.34" x3="38.1" y3="67.31000625" textsize="1.778" layer="16"/>
+<wire x1="-1.27" y1="59.68" x2="-1.27" y2="17.78" width="0" layer="20"/>
+<wire x1="-1.27" y1="59.69" x2="54.61" y2="59.69" width="0.4064" layer="20"/>
+<wire x1="54.61" y1="59.69" x2="54.61" y2="52.07" width="0.4064" layer="20"/>
+<wire x1="54.61" y1="52.07" x2="63.5" y2="52.07" width="0.4064" layer="20"/>
+<wire x1="63.5" y1="52.07" x2="63.5" y2="48.26" width="0.4064" layer="20"/>
+<wire x1="63.5" y1="48.26" x2="102.87" y2="48.26" width="0.4064" layer="20"/>
+<wire x1="102.87" y1="48.26" x2="102.87" y2="30.48" width="0.4064" layer="20"/>
+<wire x1="102.87" y1="30.48" x2="64.77" y2="30.48" width="0.4064" layer="20"/>
+<wire x1="64.77" y1="30.48" x2="64.77" y2="26.67" width="0.4064" layer="20"/>
+<wire x1="64.77" y1="26.67" x2="54.61" y2="26.67" width="0.4064" layer="20"/>
+<wire x1="54.61" y1="26.67" x2="54.61" y2="17.78" width="0.4064" layer="20"/>
+<wire x1="54.61" y1="17.78" x2="-1.27" y2="17.78" width="0.4064" layer="20"/>
+<wire x1="-1.27" y1="17.78" x2="-1.27" y2="59.69" width="0.4064" layer="20"/>
 </plain>
 <attributes>
@@
 </class>
 </classes>
-<designrules name="default">
+<designrules name="bastli">
 <description language="de">&lt;b&gt;EAGLE Design Rules&lt;/b&gt;
 &lt;p&gt;
@@
 <param name="mtCopper" value="0.035mm 0.035mm 0.035mm 0.035mm 0.035mm 0.035mm 0.035mm 0.035mm 0.035mm 0.035mm 0.035mm 0.035mm 0.035mm 0.035mm 0.035mm 0.035mm"/>
 <param name="mtIsolate" value="1.5mm 0.15mm 0.2mm 0.15mm 0.2mm 0.15mm 0.2mm 0.15mm 0.2mm 0.15mm 0.2mm 0.15mm 0.2mm 0.15mm 0.2mm"/>
-<param name="mdWireWire" value="8mil"/>
-<param name="mdWirePad" value="8mil"/>
-<param name="mdWireVia" value="8mil"/>
-<param name="mdPadPad" value="8mil"/>
-<param name="mdPadVia" value="8mil"/>
-<param name="mdViaVia" value="8mil"/>
-<param name="mdSmdPad" value="8mil"/>
-<param name="mdSmdVia" value="8mil"/>
-<param name="mdSmdSmd" value="8mil"/>
+<param name="mdWireWire" value="0.4mm"/>
+<param name="mdWirePad" value="0.4mm"/>
+<param name="mdWireVia" value="0.4mm"/>
+<param name="mdPadPad" value="0.4mm"/>
+<param name="mdPadVia" value="0.4mm"/>
+<param name="mdViaVia" value="0.4mm"/>
+<param name="mdSmdPad" value="0.4mm"/>
+<param name="mdSmdVia" value="0.4mm"/>
+<param name="mdSmdSmd" value="0.4mm"/>
 <param name="mdViaViaSameLayer" value="8mil"/>
 <param name="mnLayersViaInSmd" value="2"/>
-<param name="mdCopperDimension" value="40mil"/>
-<param name="mdDrill" value="8mil"/>
+<param name="mdCopperDimension" value="0.4mm"/>
+<param name="mdDrill" value="0.4mm"/>
 <param name="mdSmdStop" value="0mil"/>
-<param name="msWidth" value="10mil"/>
-<param name="msDrill" value="24mil"/>
+<param name="msWidth" value="0.4mm"/>
+<param name="msDrill" value="0.1mm"/>
 <param name="msMicroVia" value="9.99mm"/>
 <param name="msBlindViaRatio" value="0.5"/>
@@
 <pass name="Default">
 <param name="RoutingGrid" value="50mil"/>
-<param name="tpViaShape" value="round"/>
+<param name="tpViaShape" value="octagon"/>
 <param name="PrefDir.1" value="|"/>
 <param name="PrefDir.2" value="0"/>
@@
 <pass name="Route" refer="Default" active="yes">
 </pass>
-<pass name="Optimize1" refer="Default" active="yes">
+<pass name="Optimize1" refer="Default" active="no">
 <param name="cfVia" value="99"/>
 <param name="cfExtdStep" value="10"/>
@@
 <param name="mnRipupLevel" value="0"/>
 </pass>
-<pass name="Optimize2" refer="Optimize1" active="yes">
+<pass name="Optimize2" refer="Optimize1" active="no">
 <param name="cfNonPref" value="0"/>
 <param name="cfChangeDir" value="6"/>
@@
 <param name="cfHugging" value="0"/>
 </pass>
-<pass name="Optimize3" refer="Optimize2" active="yes">
+<pass name="Optimize3" refer="Optimize2" active="no">
 <param name="cfChangeDir" value="8"/>
 <param name="cfPadImpact" value="0"/>
 <param name="cfSmdImpact" value="0"/>
 </pass>
-<pass name="Optimize4" refer="Optimize3" active="yes">
+<pass name="Optimize4" refer="Optimize3" active="no">
 <param name="cfChangeDir" value="25"/>
 </pass>
@@
 <wire x1="40.64" y1="29.21" x2="40.64" y2="34.29" width="0.4064" layer="16"/>
 <wire x1="40.64" y1="34.29" x2="49.53" y2="34.29" width="0.4064" layer="16"/>
-<wire x1="49.53" y1="36.83" x2="55.88" y2="38.1" width="0" layer="19" extent="1-16"/>
 <wire x1="49.53" y1="34.29" x2="49.53" y2="35.56" width="0.4064" layer="16"/>
 <wire x1="49.53" y1="35.56" x2="53.34" y2="35.56" width="0.4064" layer="16"/>
@@
 <contactref element="JP6" pad="3"/>
 <contactref element="U1" pad="23"/>
-<wire x1="86.36" y1="41.91" x2="86.36" y2="43.18" width="0" layer="19" extent="1-16"/>
 <wire x1="19.05" y1="43.18" x2="21.59" y2="43.18" width="0.4064" layer="16"/>
 <wire x1="21.59" y1="43.18" x2="21.59" y2="41.91" width="0.4064" layer="16"/>
@@
 <wire x1="7.62" y1="33.02" x2="7.62" y2="27.94" width="0.4064" layer="16"/>
 </signal>
+<signal name="N$8">
+<polygon width="0.4064" layer="16">
+<vertex x="-1.27" y="59.69"/>
+<vertex x="54.61" y="59.69"/>
+<vertex x="54.61" y="52.07"/>
+<vertex x="63.5" y="52.07"/>
+<vertex x="63.5" y="48.26"/>
+<vertex x="102.87" y="48.26"/>
+<vertex x="102.87" y="31.75"/>
+<vertex x="102.87" y="30.48"/>
+<vertex x="64.77" y="30.48"/>
+<vertex x="64.77" y="27.94"/>
+<vertex x="64.77" y="26.67"/>
+<vertex x="54.61" y="26.67"/>
+<vertex x="54.61" y="17.78"/>
+<vertex x="-1.27" y="17.78"/>
+</polygon>
+</signal>
+<signal name="N$21">
+<polygon width="0.4064" layer="1">
+<vertex x="-1.27" y="59.69"/>
+<vertex x="54.61" y="59.69"/>
+<vertex x="54.61" y="52.07"/>
+<vertex x="63.5" y="52.07"/>
+<vertex x="63.5" y="48.26"/>
+<vertex x="102.87" y="48.26"/>
+<vertex x="102.87" y="30.48"/>
+<vertex x="64.77" y="30.48"/>
+<vertex x="64.77" y="26.67"/>
+<vertex x="54.61" y="26.67"/>
+<vertex x="54.61" y="17.78"/>
+<vertex x="-1.27" y="17.78"/>
+</polygon>
+</signal>
 </signals>

Commit message: OUTLINE TOP BOTTOM DRILL tilt sensor to A0 correction
Parts:
- moved JP4 14.0 mm to (86.4, 38.1)
- moved JP6 6.35 mm to (81.3, 33.0), turned to 180 degrees
- moved LED11 1.27 mm to (97.8, 39.4)
- moved LED10 1.27 mm to (92.7, 39.4)
Connections:
- removed net N$6: JP4.2, U1.4
- new net N$22: JP4.2, U1.23
- net N$18: now also U1.4; no longer U1.23
Routing:
- net N$6: track 99.1 -> 0.00 mm
- net N$22: track 0.00 -> 69.8 mm
- net N$18: track 68.6 -> 135.9 mm
- net VCC: track 157.5 -> 165.1 mm
- net GND: track 210.8 -> 209.6 mm
- net N$15: track 92.7 -> 94.0 mm
- net N$14: track 85.1 -> 86.4 mm
- net N$1: track 31.7 -> 33.0 mm
Other:
- board size 104.1 x 41.9 mm -> 105.4 x 41.9 mm

Commit message: schaltplan update
Connections:
- removed net N$15: LED11.K, U1.5
- removed net N$17: JP3.2, U1.24
- new net SWAP1: JP3.2, U1.5
- new net SWAP2: LED11.K, U1.24
- net VCC: now also U1.20
Routing:
- net N$15: track 94.0 -> 0.00 mm
- net SWAP2: track 0.00 -> 83.8 mm
- net GND: track 209.6 -> 167.6 mm
- net N$18: track 135.9 -> 100.3 mm
- net N$17: track 22.9 -> 0.00 mm
- net SWAP1: track 0.00 -> 15.2 mm
- net VCC: track 165.1 -> 167.6 mm
