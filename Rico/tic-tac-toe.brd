File: Rico/tic-tac-toe.brd (EAGLE design)
At the start: 58.1 x 64.8 mm, 18 parts, among them IC1 PCF8574P, U1 ATMEGA328P_PDIP

Commit message: ricoh: version 2 of board
* connect vcc branches
* disconnect unused pin on DIP8S
* reroute buttons to pins 2-4
* reroute piezo to use pin 5
* more efficient routing overall
Parts:
- moved JP3 10.9 mm to (58.4, 36.8), turned to 270 degrees
- moved IC2 2.54 mm to (92.7, 21.6)
Connections:
- removed net TAC1->PD4: S1.1, S1.2, U1.6
- removed net TAC2->PD5: S2.1, S2.2, U1.11
- removed net TAC3->PD3: S3.1, S3.2, U1.5
- new net TAC1->PD3: S1.1, S1.2, U1.5
- new net TAC3->PD2: S3.1, S3.2, U1.4
- net GND: no longer IC2.7
- net S$10: now also JP3.4, U1.11; no longer LD9.AR, U1.19
- net S$15: now also IC1.6, LD4.AX; no longer LD7.AR, U1.26
- net S$16: now also LD7.AR, U1.26; no longer IC1.4, LD7.AX
- net S$17: now also IC1.4, LD7.AX; no longer IC1.5, LD4.AX
- net S$18: now also IC1.11, LD2.AX; no longer IC1.6, LD2.AR
- net S$19: now also LD2.AR; no longer LD2.AX
- net S$2: now also S2.1, S2.2, U1.6; no longer JP3.4, U1.4
- net S$6: now also LD9.AR, U1.19; no longer JP1.1, LD4.C, LD5.C, LD7.C, LD9.C, U1.20, U1.21, U1.7
- net VCC: now also JP1.1, LD4.C, LD5.C, LD7.C, LD9.C, U1.20, U1.21, U1.7
Routing:
- net S$10: track 11.2 -> 96.8 mm
- net VCC: track 106.8 -> 187.4 mm
- net S$6: track 69.9 -> 10.5 mm
- net TAC2->PD5: track 36.4 -> 0.00 mm
- net TAC3->PD3: track 23.3 -> 0.00 mm
- net TAC3->PD2: track 0.00 -> 22.5 mm
- net S$18: track 35.9 -> 55.4 mm
- net TAC1->PD4: track 18.2 -> 0.00 mm
- net TAC1->PD3: track 0.00 -> 16.1 mm
- net GND: track 150.7 -> 165.5 mm
- net XTAL2: track 40.5 -> 27.9 mm
- net XTAL1: track 19.9 -> 27.2 mm
- net S$19: track 28.2 -> 31.8 mm
- net S$2: track 22.1 -> 18.8 mm
- net S$16: track 11.2 -> 8.89 mm
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Other:
- board size 58.1 x 64.8 mm -> 58.1 x 66 mm

Commit message: ricoh: board version 3
* swap XTAL1 & XTAL2
* shift M04 to leave space for piezo module
* relax routing around LD8
* adjust board size
Parts:
- moved JP3 10.2 mm to (48.3, 36.8)
Connections:
- net XTAL1: now also IC2.6, IC2.8; no longer IC2.1, IC2.4
- net XTAL2: now also IC2.1, IC2.4; no longer IC2.6, IC2.8
Routing:
- net GND: track 165.5 -> 175.7 mm
- net XTAL2: track 27.9 -> 18.3 mm
- net S$10: track 96.8 -> 94.3 mm
- net S$9: track 35.9 -> 37.1 mm
- net S$8: track 22.4 -> 23.2 mm
- net S$11: track 34.4 -> 33.6 mm
- net XTAL1: track 27.2 -> 27.7 mm
Other:
- board size 58.1 x 66 mm -> 56.8 x 66 mm
Changed lines of the file:
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@@
 <board>
 <plain>
-<wire x1="43.18" y1="12.7" x2="101.27" y2="12.7" width="0" layer="20"/>
+<wire x1="44.45" y1="12.7" x2="101.27" y2="12.7" width="0" layer="20"/>
 <wire x1="101.27" y1="12.7" x2="101.27" y2="78.73" width="0" layer="20"/>
-<wire x1="101.27" y1="78.73" x2="43.18" y2="78.73" width="0" layer="20"/>
-<wire x1="43.18" y1="78.73" x2="43.18" y2="12.7" width="0" layer="20"/>
+<wire x1="101.27" y1="78.73" x2="44.45" y2="78.73" width="0" layer="20"/>
+<wire x1="44.45" y1="78.73" x2="44.45" y2="12.7" width="0" layer="20"/>
 </plain>
 <attributes>
@@
 <element name="JP1" library="SparkFun-Connectors" package="1X02" value="M02PTH" x="78.74" y="27.94"/>
 <element name="JP2" library="SparkFun-Connectors" package="1X03" value="" x="63.5" y="27.94"/>
-<element name="JP3" library="SparkFun-Connectors" package="1X04" value="" x="58.42" y="36.83" rot="R270"/>
+<element name="JP3" library="SparkFun-Connectors" package="1X04" value="" x="48.26" y="36.83" rot="R270"/>
 <element name="IC2" library="ic-package" package="SOCKET-08" value="" x="92.71" y="21.59" rot="R180"/>
 </elements>
@@
 <wire x1="78.74" y1="38.1" x2="77.47" y2="36.83" width="0.4064" layer="16"/>
 <wire x1="77.47" y1="36.83" x2="68.58" y2="36.83" width="0.4064" layer="16"/>
-<wire x1="58.42" y1="36.83" x2="60.96" y2="36.83" width="0.4064" layer="16"/>
+<wire x1="48.26" y1="36.83" x2="60.96" y2="36.83" width="0.4064" layer="16"/>
 <wire x1="60.96" y1="36.83" x2="66.04" y2="36.83" width="0.4064" layer="16"/>
 <wire x1="66.04" y1="36.83" x2="67.31" y2="38.1" width="0.4064" layer="16"/>
@@
 <wire x1="46.99" y1="50.8" x2="49.53" y2="50.8" width="0.4064" layer="16"/>
 </signal>
-<signal name="XTAL1">
-<contactref element="U1" pad="9"/>
+<signal name="XTAL2">
 <contactref element="IC2" pad="4"/>
-<wire x1="83.82" y1="31.75" x2="83.82" y2="30.48" width="0.4064" layer="16"/>
 <wire x1="88.9" y1="25.4" x2="88.9" y2="27.94" width="0.4064" layer="16"/>
 <contactref element="IC2" pad="1"/>
 <wire x1="96.52" y1="25.4" x2="96.52" y2="27.94" width="0.4064" layer="16"/>
 <wire x1="96.52" y1="27.94" x2="88.9" y2="27.94" width="0.4064" layer="16"/>
-<wire x1="83.82" y1="31.75" x2="83.82" y2="33.02" width="0.4064" layer="16"/>
-<wire x1="83.82" y1="33.02" x2="85.09" y2="34.29" width="0.4064" layer="16"/>
-<wire x1="85.09" y1="34.29" x2="87.63" y2="34.29" width="0.4064" layer="16"/>
-<wire x1="87.63" y1="34.29" x2="87.63" y2="27.94" width="0.4064" layer="16"/>
 <wire x1="87.63" y1="27.94" x2="88.9" y2="27.94" width="0.4064" layer="16"/>
-</signal>
-<signal name="XTAL2">
+<contactref element="U1" pad="10"/>
+<wire x1="86.36" y1="31.75" x2="86.36" y2="29.21" width="0.4064" layer="16"/>
+<wire x1="86.36" y1="29.21" x2="87.63" y2="27.94" width="0.4064" layer="16"/>
+</signal>
+<signal name="XTAL1">
 <contactref element="IC2" pad="8"/>
-<contactref element="U1" pad="10"/>
-<wire x1="97.79" y1="17.78" x2="96.52" y2="17.78" width="0.4064" layer="16"/>
 <wire x1="91.44" y1="20.32" x2="96.52" y2="20.32" width="0.4064" layer="16"/>
 <contactref element="IC2" pad="6"/>
@@
 <wire x1="91.44" y1="17.78" x2="91.44" y2="20.32" width="0.4064" layer="16"/>
 <wire x1="91.44" y1="20.32" x2="86.36" y2="20.32" width="0.4064" layer="16"/>
-<wire x1="86.36" y1="20.32" x2="86.36" y2="31.75" width="0.4064" layer="16"/>
+<contactref element="U1" pad="9"/>
+<wire x1="83.82" y1="31.75" x2="83.82" y2="29.21" width="0.4064" layer="16"/>
+<wire x1="83.82" y1="29.21" x2="86.36" y2="26.67" width="0.4064" layer="16"/>
+<wire x1="86.36" y1="26.67" x2="86.36" y2="20.32" width="0.4064" layer="16"/>
 </signal>
 <signal name="RESET">
@@
 <contactref element="LD8" pad="AX"/>
 <contactref element="U1" pad="16"/>
-<wire x1="93.98" y1="39.37" x2="93.98" y2="40.64" width="0.4064" layer="16"/>
-<wire x1="93.98" y1="40.64" x2="92.71" y2="41.91" width="0.4064" layer="16"/>
-<wire x1="92.71" y1="41.91" x2="90.17" y2="41.91" width="0.4064" layer="16"/>
-<wire x1="90.17" y1="41.91" x2="88.9" y2="43.18" width="0.4064" layer="16"/>
-<wire x1="88.9" y1="43.18" x2="88.9" y2="46.99" width="0.4064" layer="16"/>
+<wire x1="93.98" y1="39.37" x2="93.98" y2="44.45" width="0.4064" layer="16"/>
+<wire x1="93.98" y1="44.45" x2="91.44" y2="44.45" width="0.4064" layer="16"/>
+<wire x1="91.44" y1="44.45" x2="88.9" y2="46.99" width="0.4064" layer="16"/>
 </signal>
 <signal name="S$8">
 <contactref element="LD6" pad="AX"/>
 <contactref element="U1" pad="17"/>
-<wire x1="91.44" y1="39.37" x2="87.63" y2="43.18" width="0.4064" layer="16"/>
-<wire x1="87.63" y1="43.18" x2="87.63" y2="58.42" width="0.4064" layer="16"/>
 <wire x1="87.63" y1="58.42" x2="88.9" y2="59.69" width="0.4064" layer="16"/>
+<wire x1="91.44" y1="39.37" x2="91.44" y2="43.18" width="0.4064" layer="16"/>
+<wire x1="91.44" y1="43.18" x2="90.17" y2="43.18" width="0.4064" layer="16"/>
+<wire x1="90.17" y1="43.18" x2="87.63" y2="45.72" width="0.4064" layer="16"/>
+<wire x1="87.63" y1="45.72" x2="87.63" y2="58.42" width="0.4064" layer="16"/>
 </signal>
 <signal name="S$9">
@@
 <contactref element="U1" pad="18"/>
 <wire x1="88.9" y1="39.37" x2="88.9" y2="40.64" width="0.4064" layer="16"/>
-<wire x1="88.9" y1="40.64" x2="86.36" y2="43.18" width="0.4064" layer="16"/>
-<wire x1="86.36" y1="43.18" x2="86.36" y2="71.12" width="0.4064" layer="16"/>
+<wire x1="86.36" y1="44.45" x2="86.36" y2="71.12" width="0.4064" layer="16"/>
 <wire x1="86.36" y1="71.12" x2="87.63" y2="72.39" width="0.4064" layer="16"/>
 <wire x1="87.63" y1="72.39" x2="88.9" y2="72.39" width="0.4064" layer="16"/>
+<wire x1="88.9" y1="39.37" x2="88.9" y2="41.91" width="0.4064" layer="16"/>
+<wire x1="88.9" y1="41.91" x2="86.36" y2="44.45" width="0.4064" layer="16"/>
 </signal>
 <signal name="S$11">
 <contactref element="LD5" pad="AR"/>
 <contactref element="U1" pad="12"/>
-<wire x1="91.44" y1="31.75" x2="91.44" y2="35.56" width="0.4064" layer="16"/>
-<wire x1="91.44" y1="35.56" x2="90.17" y2="36.83" width="0.4064" layer="16"/>
-<wire x1="90.17" y1="36.83" x2="88.9" y2="36.83" width="0.4064" layer="16"/>
-<wire x1="88.9" y1="36.83" x2="87.63" y2="38.1" width="0.4064" layer="16"/>
+<wire x1="91.44" y1="31.75" x2="91.44" y2="34.29" width="0.4064" layer="16"/>
+<wire x1="91.44" y1="34.29" x2="87.63" y2="38.1" width="0.4064" layer="16"/>
 <wire x1="87.63" y1="38.1" x2="87.63" y2="40.64" width="0.4064" layer="16"/>
 <wire x1="87.63" y1="40.64" x2="85.09" y2="43.18" width="0.4064" layer="16"/>
@@
 <contactref element="JP3" pad="4"/>
 <contactref element="U1" pad="11"/>
-<wire x1="58.42" y1="29.21" x2="55.88" y2="29.21" width="0.4064" layer="16"/>
-<wire x1="55.88" y1="29.21" x2="52.07" y2="25.4" width="0.4064" layer="16"/>
-<wire x1="52.07" y1="25.4" x2="52.07" y2="13.97" width="0.4064" layer="16"/>
+<wire x1="48.26" y1="29.21" x2="48.26" y2="17.78" width="0.4064" layer="16"/>
+<wire x1="48.26" y1="17.78" x2="52.07" y2="13.97" width="0.4064" layer="16"/>
 <wire x1="52.07" y1="13.97" x2="100.33" y2="13.97" width="0.4064" layer="16"/>
 <wire x1="100.33" y1="13.97" x2="100.33" y2="29.21" width="0.4064" layer="16"/>
