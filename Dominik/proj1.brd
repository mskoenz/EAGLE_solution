File: Dominik/proj1.brd (EAGLE design)
At the start: 100 x 80 mm, 16 parts, among them IC1 PCF8574P, U1 ATMEGA328P_PDIP

Commit message: first draft of the board
Parts:
- added IC2: (no value), ic-package:SOCKET-08
- added JP3: (no value), SparkFun-Connectors:1X04
- moved S3 149.2 mm to (78.7, 5.08)
- moved S2 131.6 mm to (69.8, 5.08)
- moved JP1 118.4 mm to (72.4, 15.2), turned to 180 degrees
- moved LD7 115.6 mm to (69.8, 71.1)
- moved LD9 115.5 mm to (82.5, 71.1)
- moved S1 113.9 mm to (61.0, 5.08)
- moved LD4 105.2 mm to (57.1, 71.1)
- moved JP2 103.8 mm to (55.9, 15.2)
- moved LD8 103.0 mm to (82.5, 59.7)
- moved LD6 102.4 mm to (69.8, 59.7)
- moved LD3 102.0 mm to (69.8, 48.3)
- moved IC1 78.2 mm to (52.1, 36.8), turned to 180 degrees
- moved LD2 78.0 mm to (57.1, 48.3)
- moved LD1 53.4 mm to (57.1, 59.7)
- moved LD5 50.6 mm to (82.5, 48.3)
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Connections:
- removed net VDD: IC1.16
- removed net VSS: IC1.8
- new net N$10: JP3.1, U1.11
- new net N$11: IC1.15, U1.27
- new net N$12: IC1.14, U1.28
- new net N$14: S2.1, U1.5
- new net N$15: S3.1, U1.6
- new net N$17: U1.17
- new net N$18: U1.16
- new net N$19: U1.15
- new net N$20: LD8.AR
- new net N$21: LD9.AR, U1.13
- new net N$22: LD4.AX
- new net N$24: IC1.12, LD1.AX
- new net N$25: LD6.AR
- new net N$26: LD5.AR
- new net N$27: LD4.AR
- new net N$28: IC1.7, LD7.AX, U1.18
- new net N$31: IC1.11, LD1.AR
- new net N$32: IC2.3, IC2.4, JP3.4, S1.3, S2.3, S3.3, U1.8
- new net N$7: IC2.6, IC2.8, U1.9
- new net N$8: IC2.1, IC2.5, U1.10
- new net N$9: LD1.C, LD2.C, LD3.C, LD4.C, LD5.C, LD6.C, LD7.C, LD8.C, LD9.C
- new net S$1: IC1.6, LD6.AX
- new net S$2: U1.14
- new net S$3: IC1.9, LD2.AR
- new net S$4: IC1.5, LD3.AR
- new net S$5: IC1.10, LD2.AX
- new net S$6: IC1.4, LD3.AX
- new net S$7: U1.12
- new net S$8: JP1.1
- net N$1: now also S1.1, U1.4; no longer LD1.AR, LD5.AX
- net N$4: now also IC1.8
- net N$5: now also IC1.16; no longer JP1.1, U1.8
Routing:
- net N$9: track 0.00 -> 212.1 mm
- net N$28: track 0.00 -> 104.1 mm
- net N$21: track 0.00 -> 95.2 mm
- net N$32: track 0.00 -> 92.7 mm
- net N$6: track 0.00 -> 72.4 mm
- net N$3: track 0.00 -> 69.8 mm
- net N$24: track 0.00 -> 68.6 mm
- net N$31: track 0.00 -> 66.0 mm
- net N$4: track 0.00 -> 59.7 mm
- net N$17: track 0.00 -> 52.1 mm
- net N$27: track 0.00 -> 52.1 mm
- net N$22: track 0.00 -> 49.5 mm
- net S$5: track 0.00 -> 41.9 mm
- net N$18: track 0.00 -> 40.6 mm
- net S$3: track 0.00 -> 39.4 mm
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Other:
- board size 100 x 80 mm -> 125.4 x 78.7 mm

Commit message: moved a few wires
Parts:
- moved IC1 2.54 mm to (54.6, 36.8)
Connections:
- net N$11 renamed S$10
- net N$12 renamed S$9
- removed net N$27: LD4.AR
- removed net N$6: JP2.3, U1.3
- net N$22: now also JP2.3, U1.3
- net N$3: now also LD4.AR
Routing:
- net N$6: track 72.4 -> 0.00 mm
- net N$22: track 49.5 -> 115.6 mm
- net N$27: track 52.1 -> 0.00 mm
- net N$3: track 69.8 -> 113.0 mm
- net S$4: track 36.8 -> 34.3 mm
- net S$9: track 5.08 -> 7.62 mm
- net S$6: track 26.7 -> 24.1 mm
- net S$5: track 41.9 -> 39.4 mm
- net S$3: track 39.4 -> 36.8 mm
- net S$10: track 5.08 -> 7.62 mm
- net S$1: track 38.1 -> 35.6 mm
- net N$5: track 15.2 -> 12.7 mm
- net N$31: track 66.0 -> 63.5 mm
- net N$4: track 59.7 -> 57.2 mm
- net N$28: track 104.1 -> 101.6 mm
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
Commit message: fixed a few issues
Connections:
- net N$9: now also IC1.3
Routing:
- net N$9: track 212.1 -> 236.2 mm
- net N$7: track 19.0 -> 26.7 mm
- net N$4: track 57.2 -> 59.7 mm
Changed lines of the file:
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@@
 <wire x1="45.72" y1="35.56" x2="73.66" y2="35.56" width="0.4064" layer="16"/>
 <wire x1="73.66" y1="35.56" x2="73.66" y2="27.94" width="0.4064" layer="16"/>
-<wire x1="73.66" y1="27.94" x2="76.2" y2="27.94" width="0" layer="19" extent="1-1"/>
+<wire x1="73.66" y1="27.94" x2="76.2" y2="27.94" width="0.4064" layer="16"/>
 </signal>
 <signal name="N$2">
@@
 <contactref element="IC2" pad="6"/>
 <wire x1="78.74" y1="15.24" x2="78.74" y2="12.7" width="0.4064" layer="16"/>
-<wire x1="78.74" y1="12.7" x2="87.63" y2="12.7" width="0.4064" layer="16"/>
+<wire x1="78.74" y1="12.7" x2="85.09" y2="12.7" width="0.4064" layer="16"/>
+<wire x1="85.09" y1="12.7" x2="87.63" y2="12.7" width="0.4064" layer="16"/>
 <wire x1="76.2" y1="20.32" x2="76.2" y2="17.78" width="0.4064" layer="16"/>
 <wire x1="76.2" y1="17.78" x2="77.47" y2="17.78" width="0.4064" layer="16"/>
 <wire x1="77.47" y1="17.78" x2="77.47" y2="15.24" width="0.4064" layer="16"/>
 <wire x1="77.47" y1="15.24" x2="78.74" y2="15.24" width="0.4064" layer="16"/>
-<wire x1="87.63" y1="12.7" x2="87.63" y2="7.62" width="0" layer="19" extent="1-1"/>
+<wire x1="87.63" y1="7.62" x2="85.09" y2="7.62" width="0.4064" layer="16"/>
+<wire x1="85.09" y1="7.62" x2="85.09" y2="12.7" width="0.4064" layer="16"/>
 </signal>
 <signal name="N$8">
@@
 <wire x1="60.96" y1="76.2" x2="69.85" y2="76.2" width="0.4064" layer="16"/>
 <wire x1="69.85" y1="71.12" x2="69.85" y2="59.69" width="0.4064" layer="16"/>
-<wire x1="69.85" y1="59.69" x2="69.85" y2="48.26" width="0.4064" layer="16"/>
+<wire x1="69.85" y1="59.69" x2="69.85" y2="53.34" width="0.4064" layer="16"/>
+<wire x1="69.85" y1="53.34" x2="69.85" y2="48.26" width="0.4064" layer="16"/>
 <wire x1="69.85" y1="71.12" x2="69.85" y2="76.2" width="0.4064" layer="16"/>
 <wire x1="69.85" y1="76.2" x2="82.55" y2="76.2" width="0.4064" layer="16"/>
@@
 <wire x1="57.15" y1="48.26" x2="57.15" y2="53.34" width="0.4064" layer="16"/>
 <wire x1="60.96" y1="64.77" x2="60.96" y2="76.2" width="0.4064" layer="16"/>
+<wire x1="69.85" y1="53.34" x2="66.04" y2="53.34" width="0.4064" layer="16"/>
+<wire x1="66.04" y1="53.34" x2="66.04" y2="40.64" width="0.4064" layer="16"/>
+<contactref element="IC1" pad="3"/>
+<wire x1="66.04" y1="40.64" x2="63.5" y2="40.64" width="0.4064" layer="16"/>
+<wire x1="58.42" y1="40.64" x2="60.96" y2="40.64" width="0.4064" layer="16"/>
+<wire x1="60.96" y1="40.64" x2="63.5" y2="40.64" width="0.4064" layer="16"/>
 </signal>
 <signal name="N$17">

Commit message: optimization
Parts:
- moved JP3 8.03 mm to (96.5, 30.5)
- moved S1 7.62 mm to (53.3, 5.08)
- moved IC1 6.84 mm to (61.0, 39.4)
- moved S2 3.81 mm to (66.0, 5.08)
- moved LD1 2.54 mm to (57.1, 62.2)
- moved LD2 2.54 mm to (57.1, 50.8)
- moved LD3 2.54 mm to (69.8, 50.8)
- moved LD5 2.54 mm to (82.5, 50.8)
- moved LD6 2.54 mm to (69.8, 62.2)
- moved LD8 2.54 mm to (82.5, 62.2)
- moved LD4 2.54 mm to (57.1, 73.7)
- moved LD7 2.54 mm to (69.8, 73.7)
- moved LD9 2.54 mm to (82.5, 73.7)
Connections:
- removed net N$4: IC1.8, JP1.2, U1.20, U1.21, U1.7
- removed net N$5: IC1.16, U1.22
- removed net S$7: U1.12
- new net S$12: JP2.3, U1.3
- new net S$13: LD7.AR, U1.18
- net N$17: now also LD9.AX
- net N$18: now also LD8.AX
- net N$19: now also LD5.AX
- net N$20: now also U1.13
- net N$21: now also U1.14; no longer U1.13
- net N$22: now also U1.25; no longer JP2.3, U1.3
- net N$26: now also U1.12
- net N$28: no longer U1.18
- net N$3: now also U1.26; no longer JP2.2, U1.2
- net N$32: now also IC1.8, U1.22
- net N$9: now also IC1.1, IC1.16, JP1.2, U1.20, U1.21, U1.7
- net S$2: now also JP2.2, U1.2; no longer U1.14
- net S$3: now also IC1.10; no longer IC1.9
- net S$5: now also IC1.9; no longer IC1.10
Routing:
- net N$32: track 92.7 -> 190.5 mm
- net N$4: track 59.7 -> 0.00 mm
- net N$28: track 101.6 -> 43.2 mm
- net N$9: track 236.2 -> 179.1 mm
- net S$13: track 0.00 -> 54.6 mm
- net N$3: track 113.0 -> 80.0 mm
- net N$22: track 115.6 -> 82.5 mm
- net N$21: track 95.2 -> 64.8 mm
- net N$20: track 26.7 -> 53.3 mm
- net S$5: track 39.4 -> 22.9 mm
- net S$7: track 16.5 -> 0.00 mm
- net N$5: track 12.7 -> 0.00 mm
- net N$24: track 66.0 -> 54.6 mm
- net N$31: track 63.5 -> 52.1 mm
- net N$26: track 30.5 -> 41.9 mm
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
Commit message: changed wire near buttons
Connections:
- new net S$7: U1.8
- net N$32: no longer U1.8
Routing:
- net N$32: track 190.5 -> 177.4 mm
- net S$7: track 0.00 -> 5.08 mm
- net S$8: track 11.4 -> 10.2 mm
Changed lines of the file:
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@@
 <contactref element="U1" pad="9"/>
 <contactref element="IC2" pad="6"/>
-<wire x1="78.74" y1="15.24" x2="78.74" y2="12.7" width="0.4064" layer="16"/>
-<wire x1="78.74" y1="12.7" x2="85.09" y2="12.7" width="0.4064" layer="16"/>
+<wire x1="77.47" y1="12.7" x2="85.09" y2="12.7" width="0.4064" layer="16"/>
 <wire x1="85.09" y1="12.7" x2="87.63" y2="12.7" width="0.4064" layer="16"/>
-<wire x1="76.2" y1="20.32" x2="76.2" y2="17.78" width="0.4064" layer="16"/>
-<wire x1="76.2" y1="17.78" x2="77.47" y2="17.78" width="0.4064" layer="16"/>
-<wire x1="77.47" y1="17.78" x2="77.47" y2="15.24" width="0.4064" layer="16"/>
-<wire x1="77.47" y1="15.24" x2="78.74" y2="15.24" width="0.4064" layer="16"/>
+<wire x1="76.2" y1="20.32" x2="76.2" y2="16.51" width="0.4064" layer="16"/>
+<wire x1="76.2" y1="16.51" x2="77.47" y2="16.51" width="0.4064" layer="16"/>
+<wire x1="77.47" y1="16.51" x2="77.47" y2="12.7" width="0.4064" layer="16"/>
 <wire x1="87.63" y1="7.62" x2="85.09" y2="7.62" width="0.4064" layer="16"/>
 <wire x1="85.09" y1="7.62" x2="85.09" y2="12.7" width="0.4064" layer="16"/>
@@
 <contactref element="U1" pad="10"/>
 <contactref element="IC2" pad="5"/>
-<wire x1="81.28" y1="16.51" x2="78.74" y2="16.51" width="0.4064" layer="16"/>
-<wire x1="78.74" y1="16.51" x2="78.74" y2="20.32" width="0.4064" layer="16"/>
+<wire x1="78.74" y1="15.24" x2="78.74" y2="20.32" width="0.4064" layer="16"/>
 <wire x1="87.63" y1="15.24" x2="91.44" y2="15.24" width="0.4064" layer="16"/>
 <wire x1="91.44" y1="15.24" x2="91.44" y2="7.62" width="0.4064" layer="16"/>
 <wire x1="91.44" y1="7.62" x2="95.25" y2="7.62" width="0.4064" layer="16"/>
-<wire x1="87.63" y1="15.24" x2="81.28" y2="15.24" width="0.4064" layer="16"/>
-<wire x1="81.28" y1="15.24" x2="81.28" y2="16.51" width="0.4064" layer="16"/>
+<wire x1="87.63" y1="15.24" x2="78.74" y2="15.24" width="0.4064" layer="16"/>
 </signal>
 <signal name="N$1">
@@
 <signal name="S$8">
 <wire x1="74.93" y1="20.32" x2="73.66" y2="20.32" width="0.4064" layer="16"/>
-<wire x1="74.93" y1="16.51" x2="74.93" y2="20.32" width="0.4064" layer="16"/>
-<wire x1="76.2" y1="16.51" x2="74.93" y2="16.51" width="0.4064" layer="16"/>
-<wire x1="76.2" y1="15.24" x2="76.2" y2="16.51" width="0.4064" layer="16"/>
+<wire x1="74.93" y1="15.24" x2="74.93" y2="20.32" width="0.4064" layer="16"/>
 <contactref element="JP1" pad="1"/>
-<wire x1="72.39" y1="15.24" x2="76.2" y2="15.24" width="0.4064" layer="16"/>
+<wire x1="72.39" y1="15.24" x2="74.93" y2="15.24" width="0.4064" layer="16"/>
+<wire x1="74.93" y1="15.24" x2="76.2" y2="15.24" width="0.4064" layer="16"/>
 </signal>
 <signal name="N$14">
@@
 <wire x1="50.8" y1="36.83" x2="50.8" y2="33.02" width="0.4064" layer="16"/>
 </signal>
+<signal name="S$7">
+<contactref element="U1" pad="8"/>
+<wire x1="74.93" y1="20.32" x2="73.66" y2="20.32" width="0.4064" layer="16"/>
+<wire x1="74.93" y1="16.51" x2="74.93" y2="20.32" width="0.4064" layer="16"/>
+</signal>
 <signal name="N$32">
 <contactref element="S2" pad="3"/>
@@
 <contactref element="S3" pad="3"/>
 <contactref element="IC2" pad="3"/>
-<contactref element="U1" pad="8"/>
 <contactref element="IC2" pad="4"/>
 <wire x1="50.0888" y1="2.8194" x2="49.53" y2="2.8194" width="0.4064" layer="16"/>
-<wire x1="49.53" y1="2.8194" x2="49.53" y2="1.27" width="0.4064" layer="16"/>
-<wire x1="49.53" y1="1.27" x2="62.23" y2="1.27" width="0.4064" layer="16"/>
-<wire x1="62.23" y1="1.27" x2="74.93" y2="1.27" width="0.4064" layer="16"/>
+<wire x1="49.53" y1="2.8194" x2="49.53" y2="5.08" width="0.4064" layer="16"/>
+<wire x1="49.53" y1="5.08" x2="62.23" y2="5.08" width="0.4064" layer="16"/>
+<wire x1="62.23" y1="5.08" x2="74.93" y2="5.08" width="0.4064" layer="16"/>
 <wire x1="75.4888" y1="2.8194" x2="74.93" y2="2.8194" width="0.4064" layer="16"/>
-<wire x1="74.93" y1="2.8194" x2="74.93" y2="1.27" width="0.4064" layer="16"/>
-<wire x1="74.93" y1="1.27" x2="83.82" y2="1.27" width="0.4064" layer="16"/>
-<wire x1="83.82" y1="1.27" x2="83.82" y2="5.08" width="0.4064" layer="16"/>
+<wire x1="74.93" y1="2.8194" x2="74.93" y2="5.08" width="0.4064" layer="16"/>
+<wire x1="74.93" y1="5.08" x2="83.82" y2="5.08" width="0.4064" layer="16"/>
 <wire x1="83.82" y1="5.08" x2="83.82" y2="11.43" width="0.4064" layer="16"/>
 <wire x1="83.82" y1="11.43" x2="76.2" y2="11.43" width="0.4064" layer="16"/>
@@
 <wire x1="97.79" y1="12.7" x2="97.79" y2="5.08" width="0.4064" layer="16"/>
 <wire x1="97.79" y1="5.08" x2="83.82" y2="5.08" width="0.4064" layer="16"/>
-<wire x1="76.2" y1="11.43" x2="76.2" y2="16.51" width="0.4064" layer="16"/>
-<wire x1="76.2" y1="16.51" x2="74.93" y2="16.51" width="0.4064" layer="16"/>
-<wire x1="74.93" y1="16.51" x2="74.93" y2="20.32" width="0.4064" layer="16"/>
-<wire x1="74.93" y1="20.32" x2="73.66" y2="20.32" width="0.4064" layer="16"/>
+<wire x1="76.2" y1="11.43" x2="76.2" y2="15.24" width="0.4064" layer="16"/>
 <wire x1="62.7888" y1="2.8194" x2="62.23" y2="2.8194" width="0.4064" layer="16"/>
-<wire x1="62.23" y1="2.8194" x2="62.23" y2="1.27" width="0.4064" layer="16"/>
-<wire x1="49.53" y1="1.27" x2="48.26" y2="1.27" width="0.4064" layer="16"/>
-<wire x1="48.26" y1="1.27" x2="48.26" y2="10.16" width="0.4064" layer="16"/>
+<wire x1="62.23" y1="2.8194" x2="62.23" y2="5.08" width="0.4064" layer="16"/>
+<wire x1="49.53" y1="5.08" x2="48.26" y2="5.08" width="0.4064" layer="16"/>
+<wire x1="48.26" y1="5.08" x2="48.26" y2="10.16" width="0.4064" layer="16"/>
 <wire x1="48.26" y1="10.16" x2="53.34" y2="10.16" width="0.4064" layer="16"/>
 <wire x1="53.34" y1="10.16" x2="53.34" y2="22.86" width="0.4064" layer="16"/>

Commit message: final version
Parts:
- moved JP3 35.8 mm to (92.7, 66.0)
- moved S1 1.27 mm to (53.3, 6.35)
- moved S2 1.27 mm to (66.0, 6.35)
- moved S3 1.27 mm to (78.7, 6.35)
Routing:
- net N$10: track 30.5 -> 69.8 mm
- net N$32: track 177.4 -> 215.5 mm
- net N$1: track 27.5 -> 26.2 mm
- net N$14: track 16.2 -> 15.0 mm
- net N$15: track 22.4 -> 21.2 mm
- added copper zone on layer 16, net S$11
Other:
- board size 125.4 x 78.7 mm -> 55.6 x 74.9 mm
